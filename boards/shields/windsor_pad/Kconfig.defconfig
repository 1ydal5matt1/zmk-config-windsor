## boards/shields/windsor_pad/Kconfig.defconfig
```kconfig
if SHIELD_WINDSOR_PAD

config ZMK_KEYBOARD_NAME
    default "Windsor Pad"

endif # SHIELD_WINDSOR_PAD
```
